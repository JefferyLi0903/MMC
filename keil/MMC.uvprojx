# Keil uVision project MMC.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MMC
  AfterMake: fromelf -cvf .\MMC.axf --vhx --32x1 -o MMC.hex
  AfterMake: fromelf -cvf .\MMC.axf -o MMC.txt
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../src/: auxiliary.c code_def.c code_def.h main.c startup_CMSDK_CM0.s channelSelection_control.c
